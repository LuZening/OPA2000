# Repository LuZening/OPA2000

## KiCad design Power_2/HighSideDriving/power.kicad_pcb

Board: 2 copper layers, 97.0 x 65.0 mm, 105 parts (0 on the bottom side), 48 nets.

Parts:
C1, C20, C24: 1nF; 0805_C
C2, C12, C25: 1uF; 0805_C
C3: 104 63V; 1206_C
C4: 63V 4.7uF; 1210_C
C5, C6, C9, C10, C15, C18, C19, C21, C22: 104; 0805_C
C7: 6.8pF NP0; 0805_C
C8: 3.3nF NP0; 0805_C
C11: 100uF 16V; CP_Elec_6.3x5.8
C13, C26: 103; 0805_C
C14: 1uF 100V; CP_Radial_D5.0mm_P2.50mm
D1: 16V; LL-34
D2: SK310; SMC(DO-214AB)_S1
D4: D_TVS; SMC(DO-214AB)_S1
D8: IFault; 0805_LED
D9: VFault; 0805_LED
D10, D11: 4148; SOD-123
D12: Power; 0805_LED
J1, J6, J7: GND; PCB-10B-M4
J2: Conn_01x02; JST_PH_B2B-PH-SM4-TB_02x2.00mm_Straight
J3: 50V in; PCB-10B-M4
J4: Conn_01x03; JST_PH_B3B-PH-SM4-TB_03x2.00mm_Straight
J5: Conn_01x04; JST_PH_B4B-PH-SM4-TB_04x2.00mm_Straight
J8: Conn_01x04; PhoenixContact_MC-G_04x3.81mm_Angled
L1: 120uH 3A; L_12.6mm_13.5mm
Q1, Q5: 2N5551; SOT-23(SOT-23-3)
Q2: SUP90P06; TO-220-External_Thermal_Mount
Q6: 8050; SOT-23(SOT-23-3)
Q7, Q8: 2N5401; SOT-23(SOT-23-3)
Q9: MJD127; TO-252-2
R1, R26: 47K 1%; 0805_R
R2: 2.2K 1%; 0805_R
R3, R4, R6, R32, R33, R40, R41, R45: 10K; 0805_R
R5, R14: 100K; 0805_R
R7: 33K; 0805_R
R8, R9, R29, R30, R31: 1K; 0805_R
R10: 2M; 0805_R
R11: 51K; 0805_R
R12: 70K 1%; 0805_R
R13, R17, R18, R21, R23, R25: 47K; 0805_R
R15: 330K; 0805_R
R16: 470K; 0805_R
R19: 68K; 0805_R
R20: 8.2K; 0805_R
R22: 2K; 0805_R
R24: 1R 1/2W; R_1812_4532Metric
R34, R35: 3.3K; 0805_R
R36, R38, R39: 10K 1%; 0805_R
R37: 6.8K 1%; 0805_R
R42: 680; 0805_R
R43, R44: 22K 1%; 0805_R
RV1: 47K; Potentiometer_Bourns_3296W_Vertical
SC1, SC2: GND; M3_Screwhole
TP1: Zener; TestPoint_Pad_1.0x1.0mm
TP2: OVX; TestPoint_Pad_1.0x1.0mm
TP3: BuckVin; TestPoint_Pad_1.0x1.0mm
TP4: ImSense; TestPoint_Pad_1.0x1.0mm
TP5: VmSense; TestPoint_Pad_1.0x1.0mm
TP7: 12V; TestPoint_Pad_1.0x1.0mm
TP8: 5V; TestPoint_Pad_1.0x1.0mm
U1, U2: LMV358; SOIC-8_150MIL
U3: TPS54260; MSOP-10-1EP_W3mm
U4: ACS758xCB-100U-PFF; Allegro_CB_PFF
U6: TL431; SOT-23(SOT-23-3)

Connections:
50Vin: C14.1, D4.2, J3.1, Q7.2, R1.1, R13.1, R17.1, R24.2, U4.4
+5V: C2.1, C6.2, C15.2, C18.2, R36.2, R38.2, R42.2, R43.1, TP8.1, U1.8, U2.8, U4.1, U6.2
+12V: C11.1, C12.1, C21.2, C22.2, D12.1, J8.1, J8.2, L1.2, R18.1, R42.1, TP7.1
/OVX: Q5.3, R21.2, R23.2, TP2.1
Earth: C1.1, C2.2, C3.2, C4.2, C6.1, C7.2, C8.2, C9.2, C11.2, C12.2, C13.1, C14.2, C15.1, C18.1, C19.1, C20.1, C21.1, C22.1, C24.1, C25.1, C26.1, D2.1, D4.1, J1.1, J2.2, J4.3, J5.4, J6.1, J7.1, J8.3, J8.4, Q1.2, Q5.2, Q6.2, R2.2, R6.1, R15.2, R16.2, R20.2, R22.2, R25.2, R26.2, R34.1, R35.1, R37.1, R39.1, R44.2, R45.2, RV1.3, U1.4, U2.4, U3.9, U3.11, U4.2, U6.3
Im_high: D8.1, D10.1, R31.1, R33.1, U1.7
Im_sense: R9.1, R29.1, R41.1, TP4.1, U2.6, U2.7
unnamed: C1.2, Q1.1, R3.2, R5.2, R6.2
unnamed: C3.1, C4.1, Q9.2, R10.1, TP3.1
unnamed: C5.1, Q8.2, Q9.3, R24.1
unnamed: C5.2, Q8.3, Q9.1, R25.1
unnamed: C7.1, R14.1, U3.8
unnamed: C8.1, R14.2
unnamed: C9.1, U3.4
unnamed: C10.1, D2.2, L1.1, U3.10
unnamed: C10.2, U3.1
unnamed: C19.2, R38.1, R39.2, U1.2
unnamed: C25.2, D10.2, R41.2, U1.5
unnamed: C26.2, D11.2, R40.2, U1.3
unnamed: D1.1, Q5.1, R16.1
unnamed: D1.2, R12.2, R26.1, RV1.2, TP1.1
unnamed: D8.2, R34.2
unnamed: D9.2, R35.2
unnamed: D12.2, R45.1
unnamed: J2.1, R29.2
unnamed: J4.1, R30.2
unnamed: J4.2, R31.2
unnamed: J5.1, R8.2
unnamed: J5.2, R9.2
unnamed: Q1.3, R7.2
unnamed: Q2.1, Q7.3, R4.2, R5.1, R7.1
unnamed: Q2.3, R4.1, U4.5
unnamed: Q6.1, R32.2, R33.2
unnamed: Q7.1, R17.2, R21.1
unnamed: Q8.1, R23.1
unnamed: R10.2, R11.1, U3.3
unnamed: R11.2, R22.1
unnamed: R12.1, R13.2, RV1.1
unnamed: R15.1, U3.5
unnamed: R18.2, R19.1
unnamed: R19.2, R20.1, U3.7
unnamed: R36.1, R37.2, U1.6
unnamed: R43.2, R44.1, U6.1
PWR_on: J5.3, Q6.3, R3.1
VImain: C13.2, C20.2, U2.5, U4.3
VVm_sense: C24.2, R1.2, R2.1, U2.3
Vm_high: D9.1, D11.1, R30.1, R32.1, U1.1
Vm_sense: R8.1, R40.1, TP5.1, U2.1, U2.2

File Power_2/HighSideDriving/power_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"1nF","desc","C1,C20,C24,","0805_C","libref","2","3","","",
"1uF","desc","C2,C12,C25,","0805_C","libref","2","3","","",
"104 63V","desc","C3,","1206_C","libref","2","1","","",
"63V 4.7uF","desc","C4,","1210_C","libref","2","1","","",
"104 ","desc","C5,","0805_C","libref","2","1","","",
"104","desc","C6,C9,C10,C15,C18,C19,C21,C22,","0805_C","libref","2","8","","",
"6.8pF NP0","desc","C7,","0805_C","libref","2","1","","",
"3.3nF NP0","desc","C8,","0805_C","libref","2","1","","",
"100uF 16V","desc","C11,","CP_Elec_6.3x5.8","libref","2","1","","",
"103","desc","C13,C26,","0805_C","libref","2","2","","",
"16V","desc","D1,","LL-34","libref","2","1","","",
"SK310","desc","D2,","SMC(DO-214AB)_S1","libref","2","1","","",
"D_TVS","desc","D4,","SMC(DO-214AB)_S1","libref","2","1","","",
"IFault","desc","D8,","0805_LED","libref","2","1","","",
"VFault","desc","D9,","0805_LED","libref","2","1","","",
"4148","desc","D10,D11,","SOD-123","libref","2","2","","",
"Power","desc","D12,","0805_LED","libref","2","1","","",
"Conn_01x02","desc","J2,","JST_PH_B2B-PH-SM4-TB_02x2.00mm_Straight","libref","4","1","","",
"Conn_01x03","desc","J4,","JST_PH_B3B-PH-SM4-TB_03x2.00mm_Straight","libref","5","1","","",
"Conn_01x04","desc","J5,","JST_PH_B4B-PH-SM4-TB_04x2.00mm_Straight","libref","6","1","","",
"120uH 3A","desc","L1,","L_12.6mm_13.5mm","libref","2","1","","",
"2N5551","desc","Q1,Q5,","SOT-23(SOT-23-3)","libref","3","2","","",
"SUP90P06","desc","Q2,","TO-220-External_Thermal_Mount","libref","3","1","","",
"8050","desc","Q6,","SOT-23(SOT-23-3)","libref","3","1","","",
"2N5401","desc","Q7,Q8,","SOT-23(SOT-23-3)","libref","3","2","","",
"MJD127","desc","Q9,","TO-252-2","libref","3","1","","",
"47K 1%","desc","R1,R26,","0805_R","libref","2","2","","",
"2.2K 1%","desc","R2,","0805_R","libref","2","1","","",
"10K","desc","R3,R4,R6,R32,R33,R40,R41,R45,","0805_R","libref","2","8","","",
"100K","desc","R5,R14,","0805_R","libref","2","2","","",
"33K","desc","R7,","0805_R","libref","2","1","","",
"1K","desc","R8,R9,R29,R30,R31,","0805_R","libref","2","5","","",
"2M","desc","R10,","0805_R","libref","2","1","","",
"51K","desc","R11,","0805_R","libref","2","1","","",
"70K 1%","desc","R12,","0805_R","libref","2","1","","",
"47K","desc","R13,R17,R18,R21,R23,R25,","0805_R","libref","2","6","","",
"330K","desc","R15,","0805_R","libref","2","1","","",
"470K","desc","R16,","0805_R","libref","2","1","","",
"68K","desc","R19,","0805_R","libref","2","1","","",
"8.2K","desc","R20,","0805_R","libref","2","1","","",
"2K","desc","R22,","0805_R","libref","2","1","","",
"1R 1/2W","desc","R24,","R_1812_4532Metric","libref","2","1","","",
"3.3K","desc","R34,R35,","0805_R","libref","2","2","","",
"10K 1%","desc","R36,R38,R39,","0805_R","libref","2","3","","",
"6.8K 1%","desc","R37,","0805_R","libref","2","1","","",
"680","desc","R42,","0805_R","libref","2","1","","",
"22K 1%","desc","R43,R44,","0805_R","libref","2","2","","",
"LMV358","desc","U1,U2,","SOIC-8_150MIL","libref","8","2","","",
"TPS54260","desc","U3,","MSOP-10-1EP_W3mm","libref","11","1","","",
"TL431","desc","U6,","SOT-23(SOT-23-3)","libref","3","1","","",
"Zener","desc","TP1,","TestPoint_Pad_1.0x1.0mm","libref","1","1","","",
"OVX","desc","TP2,","TestPoint_Pad_1.0x1.0mm","libref","1","1","","",
"BuckVin","desc","TP3,","TestPoint_Pad_1.0x1.0mm","libref","1","1","","",
"ImSense","desc","TP4,","TestPoint_Pad_1.0x1.0mm","libref","1","1","","",
"VmSense","desc","TP5,","TestPoint_Pad_1.0x1.0mm","libref","1","1","","",
"12V","desc","TP7,","TestPoint_Pad_1.0x1.0mm","libref","1","1","","",
"5V","desc","TP8,","TestPoint_Pad_1.0x1.0mm","libref","1","1","","",
"Through Hole Items ",
"1uF 100V","desc","C14,","CP_Radial_D5.0mm_P2.50mm","libref","2","1","","",
"GND","desc","J1,J6,J7,","PCB-10B-M4","libref","2","3","","",
"50V in","desc","J3,","PCB-10B-M4","libref","2","1","","",
"Conn_01x04","desc","J8,","PhoenixContact_MC-G_04x3.81mm_Angled","libref","4","1","","",
"ACS758xCB-100U-PFF","desc","U4,","Allegro_CB_PFF","libref","37","1","","",
"47K","desc","RV1,","Potentiometer_Bourns_3296W_Vertical","libref","3","1","","",
"GND","desc","SC1,SC2,","M3_Screwhole","libref","7","2","","",

## KiCad design RF_2/Directional_Coupler_Linear/Directional_coupler.kicad_pcb

Board: 2 copper layers, 60.0 x 67.5 mm, 66 parts (2 on the bottom side), 33 nets.

Parts:
C1: 10p 1KV; 1206_C
C2, C4, C8, C14, C16: 104; 0805_C
C3, C9, C10, C15: 1uF; 0805_C
C5, C13: x; 0805_C
C6: 10n; 0805_C
C12: 10nF; 0805_C
D1, D2, D3, D5, D7, D8, D9: 1N5819; SOD-123
D4, D6: BAT54S; SOT-23(SOT-23-3)
J1: RF in; RF_conn_pad
J2: Singal; JST_XH_S06B-XH-A_06x2.50mm_Angled
J3: RF out; RF_conn_pad
J4: Singal; JST_PH_S6B-PH-SM4-TB_1x06-1MP_P2.00mm_Horizontal
J5: FWD; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
J6: REV; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
JP1, JP2: 10n; 0805_C
L1: 0Ohm; 0805_L
L2: 10uH; 0805_L
R1, R2, R3, R16, R17, R18: 100; 0805_R
R4, R14: 1K; R_0805
R5, R15: 1M; R_0805
R6, R13: 100K; R_0805
R7, R12: 330; 1206_R
R8, R11: 120; 1206_R
R9, R10: 56 2W; R_2512
R19, R20: 220K; 0805_R
SC1, SC2, SC3, SC4: GND; M3_Screwhole
T1, T1#2: 1T; 5943004901
T2, T2#2: 33T; 5943004901
U1, U5: GS8552; SOIC-8_150MIL
U2: TLV9001; SOT-23-5
U3: ME6211C33M5G-N; SOT-23-5
U4: RS8051; SOT-23-5

Connections:
+3V3: C2.2, C4.2, C10.1, C14.2, C16.2, D3.2, D7.2, U1.8, U2.5, U3.5, U4.5, U5.8
+5V: D5.1, J2.1, J4.1
FWD: J2.3, J4.3, R1.1
FWD_peak: J2.2, J4.2, J5.1, R2.1
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C8.1, C9.2, C10.2, C12.1, C13.2, C14.1, C15.2, C16.1, D4.1, D6.1, J1.2, J2.6, J3.2, J4.6, J5.2, J6.2, R5.1, R6.1, R7.1, R9.2, R10.2, R12.1, R13.1, R15.1, SC1.1, SC2.1, SC3.1, SC4.1, U1.4, U2.2, U3.2, U4.2, U5.4
unnamed: C1.2, J1.1
unnamed: C3.1, R3.1, R5.2, U1.3
unnamed: C5.2, D3.1, L1.1, U1.5, U2.3
unnamed: C6.2, D4.2, R19.2
unnamed: C8.2, C9.1, D5.2, U3.1, U3.3
unnamed: C12.2, D6.2, R20.2
unnamed: C13.1, D7.1, L2.2, U4.3, U5.5
unnamed: C15.1, R15.2, R16.2, U5.3
unnamed: D1.1, D2.2, U2.1
unnamed: D1.2, R3.2
unnamed: D2.1, R4.2, U2.4
unnamed: D4.3, JP1.2
unnamed: D6.3, JP2.1
unnamed: D8.1, R14.1, U4.4
unnamed: D8.2, D9.1, U4.1
unnamed: D9.2, R16.1
unnamed: JP1.1, R7.2, R8.2
unnamed: JP2.2, R11.1, R12.2
unnamed: L1.2, R6.2, R19.1
unnamed: L2.1, R13.2, R20.1
unnamed: R1.2, U1.6, U1.7
unnamed: R2.2, R4.1, U1.1, U1.2
unnamed: R8.1, R9.1
unnamed: R10.1, R11.2
unnamed: R14.2, R17.1, U5.1, U5.2
unnamed: R18.1, U5.6, U5.7
REV: J2.5, J4.5, R18.2
REV_peak: J2.4, J4.4, J6.1, R17.2

## KiCad design MCU/MCU_2/MCU.kicad_pcb

Parts:
C1, C2: 20; 0805_C
C3, C4, C6, C7, C8, C9, C10, C37, C40, C59, C64, C66, C67, C70: 104; 0805_C
C11: 10uF; 0805_C
C57, C58: 2.2uF; 0805_C
D24: LED; 0805_LED_S1
J2: LPF; JST_PH_B8B-PH-SM4-TB_1x08-1MP_P2.00mm_Vertical
J3: Conn_02x20_Odd_Even; TK043F1508_Board
J4: SWD; PinHeader_1x04_P2.54mm_Vertical
J10: RotEnc; JST_PH_B5B-PH-SM4-TB_1x05-1MP_P2.00mm_Vertical
L1: 600Ohm; 0805_L
R1, R2, R3: 100; 0805_R
R7, R8, R9, R10, R11, R12, R13, R84: 4.7K; 0805_R
U1: 74HC04; SOIC-14_150MIL
U2: STM32F407VETx; LQFP-100_14X14X05P
U15: M24C02-FMN; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3V3: C4.1, C6.1, C7.1, C8.1, C9.1, C37.2, C40.1, C70.1, D24.A, L1.2, U1.14 (VCC), U2.6 (VBAT), U2.11 (VDD), U2.19 (VDD), U2.28 (VDD), U2.50 (VDD), U2.75 (VDD), U2.100 (VDD), U15.8 (VCC); also elsewhere on the board
+12V: J2.8; also elsewhere on the board
/ADC1_3: U2.26 (PA3); also elsewhere on the board
/ADC1_4: U2.29 (PA4); also elsewhere on the board
/ADC1_5: U2.30 (PA5); also elsewhere on the board
/ADC1_6: U2.31 (PA6); also elsewhere on the board
/ADC1_7: U2.32 (PA7); also elsewhere on the board
/ADC1_8: U2.35 (PB0); also elsewhere on the board
/ADC1_9: U2.36 (PB1); also elsewhere on the board
/ADC1_14: U2.33 (PC4); also elsewhere on the board
/ADC3_10: U2.15 (PC0); also elsewhere on the board
/ADC3_11: U2.16 (PC1); also elsewhere on the board
/ADC3_12: U2.17 (PC2); also elsewhere on the board
/ADC3_13: U2.18 (PC3); also elsewhere on the board
/BL: J3.37, U2.53 (PB14)
/CAN_RX: U2.51 (PB12); also elsewhere on the board
/CAN_TX: U2.52 (PB13); also elsewhere on the board
/CS: J3.12, U2.88 (PD7)
/D0: J3.15, U2.61 (PD14)
/D1: J3.18, U2.62 (PD15)
/D2: J3.17, U2.81 (PD0)
/D3: J3.20, U2.82 (PD1)
/D4: J3.19, U2.38 (PE7)
/D5: J3.22, U2.39 (PE8)
/D6: J3.21, U2.40 (PE9)
/D7: J3.24, U2.41 (PE10)
/D8: J3.23, U2.42 (PE11)
/D9: J3.26, U2.43 (PE12)
/D10: J3.25, U2.44 (PE13)
/D11: J3.28, U2.45 (PE14)
/D12: J3.27, U2.46 (PE15)
/D13: J3.30, U2.55 (PD8)
/D14: J3.29, U2.56 (PD9)
/D15: J3.32, U2.57 (PD10)
/D16: J3.9
/D17: J3.10
/D18: J3.7
/D19: J3.8
/D20: J3.5
/D21: J3.6
/D22: J3.3
/D23: J3.4
/EEP_SCL: U2.25 (PA2), U15.6 (SCL)
/EEP_SDA: U2.24 (PA1), U15.5 (SDA)
/EEP_WP: U2.34 (PC5), U15.7 (~WC)
/ENC_A: C67.2, R1.2, U2.58 (PD11)
/ENC_B: C66.2, R3.2, U2.59 (PD12)
/ENC_SW: C64.2, R2.2, U2.64 (PC7)
/MCU_STATE: R84.1, U2.23 (PA0)
/NRST: C3.1, J4.1, U2.14 (NRST)
/RD: J3.13, U2.85 (PD4)
/RESX: J3.16, U2.63 (PC6)
/RS: J3.11, U2.60 (PD13)
/RX: U2.69 (PA10); also elsewhere on the board
/RX3: U2.48 (PB11); also elsewhere on the board
/SWCLK: J4.2, U2.76 (PA14)
/SWDIO: J4.3, U2.72 (PA13)
/TX: U2.68 (PA9); also elsewhere on the board
/TX3: U2.47 (PB10); also elsewhere on the board
/T_BUSY: J3.31, U2.95 (PB8)
/T_CS: J3.34, U2.96 (PB9)
/T_INT: J3.38, U2.54 (PB15)
/T_MISO: J3.36, U2.90 (PB4)
/T_MOSI: J3.35, U2.91 (PB5)
/T_SCK: J3.33, U2.89 (PB3)
/WR: J3.14, U2.86 (PD5)
/X1: C1.1, U2.12 (PH0), Y1.1
/X2: C2.1, U2.13 (PH1), Y1.3
ALC_trig: U2.70 (PA11)
FAN1: U2.83 (PD2); also elsewhere on the board
FAN2: U2.84 (PD3); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C37.1, C40.2, C57.2, C58.2, C64.1, C66.1, C67.1, C70.2, J2.1, J3.1, J3.40, J4.4, J10.3, J10.4, R13.2, U1.7 (GND), U2.10 (VSS), U2.27 (VSS), U2.74 (VSS), U2.99 (VSS), U15.1 (E0), U15.2 (E1), U15.3 (E2), U15.4 (VSS), Y1.2, Y1.4; also elsewhere on the board
GNDA: C10.2, C11.2, C59.2, U2.20 (VSSA); also elsewhere on the board
unnamed: C57.1, U2.49 (VCAP_1)
unnamed: C58.1, U2.73 (VCAP_2)
unnamed: D24.K, R84.2
unnamed: J2.2, R12.1
unnamed: J2.3, R11.1
unnamed: J2.4, R10.2
unnamed: J2.5, R9.2
unnamed: J2.6, R8.1
unnamed: J2.7, R7.1
unnamed: J10.1, R1.1
unnamed: J10.2, R2.1
unnamed: J10.5, R3.1
unnamed: R7.2, U1.2
unnamed: R8.2, U1.4
unnamed: R9.1, U1.6
unnamed: R10.1, U1.12
unnamed: R11.2, U1.10
unnamed: R12.2, U1.8
unnamed: R13.1, U2.94 (BOOT0)
PWR_on_sig: U2.97 (PE0); also elsewhere on the board
PrtctSig: U2.9 (PC15); also elsewhere on the board
PwrOnSig: U2.8 (PC14); also elsewhere on the board
REV2_HIGH: U2.92 (PB6); also elsewhere on the board
RF_12_ON: U2.37 (PB2)
SEL1: U1.1, U2.7 (PC13)
SEL2: U1.3, U2.5 (PE6)
SEL3: U1.5, U2.4 (PE5)
SEL4: U1.13, U2.3 (PE4)
SEL5: U1.11, U2.2 (PE3)
SEL6: U1.9, U2.1 (PE2)
Temp1_HIGH: U2.78 (PC10); also elsewhere on the board
Temp2_HIGH: U2.77 (PA15); also elsewhere on the board
Transmit: U2.71 (PA12); also elsewhere on the board
VBL: J3.39; also elsewhere on the board
VDDA: C10.1, C11.1, L1.1, U2.22 (VDDA)
VREF: C59.1, U2.21 (VREF+); also elsewhere on the board
Vm_HIGH: U2.80 (PC12); also elsewhere on the board
\Fatal: U2.87 (PD6); also elsewhere on the board
\Im_HIGH: U2.79 (PC11); also elsewhere on the board
\Overdrive: U2.98 (PE1); also elsewhere on the board
\REV1_HIGH: U2.93 (PB7); also elsewhere on the board
\SpareSig: U2.66 (PC9); also elsewhere on the board

Notes on the sheet:
LOW EFFECTIVE
A18
Back light HIGH Effective
修改： 板上数字ALC信号与RFOUT ALC信号混合

Parts:
C12, C13, C14, C15, C16, C17, C18, C20, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C38, C65: 104; 0805_C
C19, C21: 10uF; 0805_C
D5, D6, D7: SD103; SOD-123
J5: PowerSense; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J6: NTC1; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J7: NTC2; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J8: SWR1; JST_PH_B6B-PH-SM4-TB_1x06-1MP_P2.00mm_Vertical
J9: SWR2; JST_PH_B6B-PH-SM4-TB_1x06-1MP_P2.00mm_Vertical
J19: RF; JST_PH_B8B-PH-SM4-TB_1x08-1MP_P2.00mm_Vertical
Q1, Q4, Q6, Q7: DTC144E; SOT-23(SOT-23-3)
R4, R14, R16, R17, R19, R20, R53, R64: 10K; 0805_R
R15, R18, R22, R23, R24, R25, R26, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R73: 1K; 0805_R
R21: 2.2K; 0805_R
R39, R40: 3.3K; 0805_R
U3, U5: LMV358; SOIC-8_150MIL
U4, U6, U7: LMV324; SOIC-14_150MIL

Connections:
+3V3: C13.1, C14.1, C17.1, C20.1, C22.1, C23.1, C38.1, J6.1, J7.1, R4.2, R14.2, R16.2, R17.2, R19.2, R21.2, R24.2, R29.2, R64.2, U3.8 (V+), U4.4 (V+), U5.8 (V+), U6.4 (V+), U7.4 (V+); also elsewhere on the board
/ADC1_3: U7.6 (-), U7.7; also elsewhere on the board
/ADC1_4: U7.1, U7.2 (-); also elsewhere on the board
/ADC1_5: U7.8, U7.9 (-); also elsewhere on the board
/ADC1_6: U7.13 (-), U7.14; also elsewhere on the board
/ADC1_7: U6.6 (-), U6.7; also elsewhere on the board
/ADC1_8: U6.1, U6.2 (-); also elsewhere on the board
/ADC1_9: U5.5 (+), U6.8, U6.9 (-); also elsewhere on the board
/ADC1_14: U6.13 (-), U6.14; also elsewhere on the board
/ADC3_10: U3.1, U3.2 (-); also elsewhere on the board
/ADC3_11: U3.6 (-), U3.7; also elsewhere on the board
/ADC3_12: U4.1, U4.2 (-), U4.6 (-); also elsewhere on the board
/ADC3_13: U4.8, U4.9 (-), U4.13 (-); also elsewhere on the board
FWD1: J8.3, R36.1
FWD2: J9.3, R32.1
FWDpeak1: J8.2, R35.1
FWDpeak2: J9.2, R31.1
GNDA: C12.1, C13.2, C14.2, C15.2, C16.1, C17.2, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C38.2, C65.2, J5.4, J8.6, J9.6, J19.8, Q1.2 (E), Q4.2 (E), Q6.2 (E), Q7.2 (E), R20.1, R22.1, R25.1, R30.1, R39.1, R40.1, R53.1, U3.4 (V-), U4.11 (V-), U5.4 (V-), U6.11 (V-), U7.11 (V-); also elsewhere on the board
Im_sense: J5.2, R18.1
ImainFault: J19.2, Q1.1 (B)
unnamed: C12.2, R21.1, R22.2, U4.5 (+)
unnamed: C15.1, R15.2, U3.3 (+)
unnamed: C16.2, R18.2, U3.5 (+)
unnamed: C18.2, R24.1, R25.2, U4.12 (+)
unnamed: C24.1, R31.2, U6.3 (+)
unnamed: C25.1, R32.2, U6.5 (+)
unnamed: C26.1, R33.2, U6.10 (+)
unnamed: C27.1, R34.2, U6.12 (+)
unnamed: C28.1, R35.2, U7.3 (+)
unnamed: C29.1, R36.2, U7.5 (+)
unnamed: C30.1, R37.2, U7.10 (+)
unnamed: C31.1, R38.2, U7.12 (+)
unnamed: C65.1, J19.1, R73.1
unnamed: R23.2, U4.10 (+)
unnamed: R26.2, U4.3 (+)
unnamed: R29.1, R30.2, U5.6 (-)
unnamed: R53.2, R64.1, U5.2 (-)
PWR_on_sig: J5.3, R20.2; also elsewhere on the board
PrtctSig: R73.2; also elsewhere on the board
PwrOnSig: J19.6; also elsewhere on the board
REV1: J8.5, R38.1
REV2: J9.5, R34.1
REV2_HIGH: U5.7; also elsewhere on the board
REVpeak1: J8.4, R37.1
REVpeak2: J9.4, R33.1
RevFault: J19.3, Q6.1 (B)
SpareSig1: J19.7, Q7.1 (B)
Temp1: J6.2, R26.1, R40.2
Temp1_HIGH: U4.7; also elsewhere on the board
Temp2: J7.2, R23.1, R39.2
Temp2_HIGH: U4.14; also elsewhere on the board
VgFault: J19.4, Q4.1 (B)
VgSense: J19.5
Vm_HIGH: U5.1; also elsewhere on the board
Vm_sense: J5.1, R15.1, U5.3 (+)
\Fatal: D5.1 (A), D6.1 (A), D7.1 (A), R4.1; also elsewhere on the board
\Im_HIGH: D5.2 (K), Q1.3 (C), R14.1; also elsewhere on the board
\Overdrive: D7.2 (K), Q4.3 (C), R17.1; also elsewhere on the board
\REV1_HIGH: D6.2 (K), Q6.3 (C), R16.1; also elsewhere on the board
\SpareSig: Q7.3 (C), R19.1; also elsewhere on the board

Notes on the sheet:
Power Enable Signal Low Effect
NTC
Approx 70C
Approx 50C
Limit ADC at 2.6V Approx. Vmain=58.5V
